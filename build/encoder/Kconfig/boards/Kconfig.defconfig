## build/encoder/Kconfig/boards/Kconfig.defconfig
```kconfig
# Load Zephyr board defconfig descriptions.
osource "C:/zephyrproject/zephyr/boards/espressif/esp32s3_devkitc/Kconfig.defconfig"
```
